FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# SRC_URI:append = " file://0001-sc7f0-hdmi-debug-prints.patch"
SRC_URI:append = " file://0002-sc7f0-rx-clkout1-obuftds-enable.patch"
